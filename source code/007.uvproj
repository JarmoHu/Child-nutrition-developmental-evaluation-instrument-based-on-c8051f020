# Keil uVision project 007.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: 007 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c keyout.c lcdcontrol.c who.c funcf020.c
